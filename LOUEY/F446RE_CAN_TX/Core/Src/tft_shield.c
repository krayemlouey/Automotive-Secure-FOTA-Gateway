#include "tft_shield.h"

/* Table de police standard ASCII 8x16 (caractères ASCII de 32 ' ' à 126 '~') */
static const uint8_t font_8x16[95][16] = {
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // Espace
    {0x00,0x00,0x18,0x3C,0x3C,0x3C,0x18,0x18,0x18,0x00,0x18,0x18,0x00,0x00,0x00,0x00}, // !
    {0x00,0x66,0x66,0x66,0x24,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // "
    {0x00,0x00,0x6C,0x6C,0xFE,0x6C,0x6C,0x6C,0xFE,0x6C,0x6C,0x00,0x00,0x00,0x00,0x00}, // #
    {0x18,0x18,0x7C,0xC6,0xC2,0xC0,0x7C,0x06,0x06,0x86,0xC6,0x7C,0x18,0x18,0x00,0x00}, // $
    {0x00,0x00,0x00,0x00,0xC2,0xC6,0x0C,0x18,0x30,0x60,0xC6,0x86,0x00,0x00,0x00,0x00}, // %
    {0x00,0x00,0x38,0x6C,0x6C,0x38,0x76,0xDC,0xCC,0xCC,0xCC,0x76,0x00,0x00,0x00,0x00}, // &
    {0x00,0x30,0x30,0x18,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '
    {0x00,0x0C,0x18,0x30,0x30,0x60,0x60,0x60,0x60,0x30,0x30,0x18,0x0C,0x00,0x00,0x00}, // (
    {0x00,0x30,0x18,0x0C,0x0C,0x06,0x06,0x06,0x06,0x0C,0x0C,0x18,0x30,0x00,0x00,0x00}, // )
    {0x00,0x00,0x00,0x66,0x3C,0xFF,0x3C,0x66,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // *
    {0x00,0x00,0x00,0x18,0x18,0x7E,0x18,0x18,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // +
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x18,0x30,0x00,0x00,0x00}, // ,
    {0x00,0x00,0x00,0x00,0x00,0x00,0xFE,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // -
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x00}, // .
    {0x00,0x00,0x02,0x06,0x0C,0x18,0x30,0x60,0xC0,0x80,0x00,0x00,0x00,0x00,0x00,0x00}, // /
    {0x00,0x00,0x7C,0xC6,0xC6,0xCE,0xD6,0xE6,0xC6,0xC6,0xC6,0x7C,0x00,0x00,0x00,0x00}, // 0
    {0x00,0x00,0x18,0x38,0x78,0x18,0x18,0x18,0x18,0x18,0x18,0x7E,0x00,0x00,0x00,0x00}, // 1
    {0x00,0x00,0x7C,0xC6,0x06,0x0C,0x18,0x30,0x60,0xC0,0xC6,0xFE,0x00,0x00,0x00,0x00}, // 2
    {0x00,0x00,0x7C,0xC6,0x06,0x06,0x3C,0x06,0x06,0x06,0xC6,0x7C,0x00,0x00,0x00,0x00}, // 3
    {0x00,0x00,0x0C,0x1C,0x3C,0x6C,0xCC,0xFE,0x0C,0x0C,0x0C,0x1E,0x00,0x00,0x00,0x00}, // 4
    {0x00,0x00,0xFE,0xC0,0xC0,0xC0,0xFC,0x06,0x06,0x06,0xC6,0x7C,0x00,0x00,0x00,0x00}, // 5
    {0x00,0x00,0x38,0x60,0xC0,0xC0,0xFC,0xC6,0xC6,0xC6,0xC6,0x7C,0x00,0x00,0x00,0x00}, // 6
    {0x00,0x00,0xFE,0xC6,0x06,0x0C,0x18,0x30,0x30,0x60,0x60,0x60,0x00,0x00,0x00,0x00}, // 7
    {0x00,0x00,0x7C,0xC6,0xC6,0xC6,0x7C,0xC6,0xC6,0xC6,0xC6,0x7C,0x00,0x00,0x00,0x00}, // 8
    {0x00,0x00,0x7C,0xC6,0xC6,0xC6,0x7E,0x06,0x06,0x06,0x0C,0x78,0x00,0x00,0x00,0x00}, // 9
    {0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x00,0x00}, // :
    {0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x00,0x18,0x18,0x30,0x00,0x00,0x00,0x00}, // ;
    {0x00,0x06,0x0C,0x18,0x30,0x60,0xC0,0x60,0x30,0x18,0x0C,0x06,0x00,0x00,0x00,0x00}, // <
    {0x00,0x00,0x00,0x00,0xFE,0x00,0x00,0xFE,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // =
    {0x00,0x60,0x30,0x18,0x0C,0x06,0x03,0x06,0x0C,0x18,0x30,0x60,0x00,0x00,0x00,0x00}, // >
    {0x00,0x00,0x7C,0xC6,0xC6,0x0C,0x18,0x18,0x18,0x00,0x18,0x18,0x00,0x00,0x00,0x00}, // ?
    {0x00,0x00,0x7C,0xC6,0xC6,0xDE,0xDE,0xDE,0xDC,0xC0,0xC6,0x7C,0x00,0x00,0x00,0x00}, // @
    {0x00,0x00,0x18,0x3C,0x66,0xC3,0xC3,0xFF,0xC3,0xC3,0xC3,0xC3,0x00,0x00,0x00,0x00}, // A
    {0x00,0x00,0xFC,0x66,0x66,0x66,0x7C,0x66,0x66,0x66,0x66,0xFC,0x00,0x00,0x00,0x00}, // B
    {0x00,0x00,0x3C,0x66,0xC3,0xC0,0xC0,0xC0,0xC0,0xC3,0x66,0x3C,0x00,0x00,0x00,0x00}, // C
    {0x00,0x00,0xF8,0x6C,0x66,0x66,0x66,0x66,0x66,0x66,0x6C,0xF8,0x00,0x00,0x00,0x00}, // D
    {0x00,0x00,0xFE,0x62,0x62,0x68,0x78,0x68,0x60,0x62,0x62,0xFE,0x00,0x00,0x00,0x00}, // E
    {0x00,0x00,0xFE,0x66,0x62,0x68,0x78,0x68,0x60,0x60,0x60,0xF0,0x00,0x00,0x00,0x00}, // F
    {0x00,0x00,0x3C,0x66,0xC3,0xC0,0xC0,0xDE,0xC3,0xC3,0x66,0x3C,0x00,0x00,0x00,0x00}, // G
    {0x00,0x00,0xC3,0xC3,0xC3,0xC3,0xFF,0xC3,0xC3,0xC3,0xC3,0xC3,0x00,0x00,0x00,0x00}, // H
    {0x00,0x00,0x7E,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x7E,0x00,0x00,0x00,0x00}, // I
    {0x00,0x00,0x1E,0x06,0x06,0x06,0x06,0x06,0x06,0xC6,0xC6,0x7C,0x00,0x00,0x00,0x00}, // J
    {0x00,0x00,0xC6,0xCC,0xD8,0xF0,0xF8,0xDC,0xCE,0xC6,0xC6,0xC6,0x00,0x00,0x00,0x00}, // K
    {0x00,0x00,0xF0,0x60,0x60,0x60,0x60,0x60,0x60,0x62,0x66,0xFE,0x00,0x00,0x00,0x00}, // L
    {0x00,0x00,0xC3,0xE7,0xFF,0xDB,0xC3,0xC3,0xC3,0xC3,0xC3,0xC3,0x00,0x00,0x00,0x00}, // M
    {0x00,0x00,0xC3,0xE3,0xF3,0xDB,0xCF,0xC7,0xC3,0xC3,0xC3,0xC3,0x00,0x00,0x00,0x00}, // N
    {0x00,0x00,0x7C,0xC6,0xC6,0xC6,0xC6,0xC6,0xC6,0xC6,0xC6,0x7C,0x00,0x00,0x00,0x00}, // O
    {0x00,0x00,0xFC,0x66,0x66,0x66,0x7C,0x60,0x60,0x60,0x60,0xF0,0x00,0x00,0x00,0x00}, // P
    {0x00,0x00,0x7C,0xC6,0xC6,0xC6,0xC6,0xC6,0xC6,0xD6,0xDE,0x7C,0x0C,0x0E,0x00,0x00}, // Q
    {0x00,0x00,0xFC,0x66,0x66,0x66,0x7C,0x6C,0x66,0x66,0x66,0xE3,0x00,0x00,0x00,0x00}, // R
    {0x00,0x00,0x7C,0xC6,0xC6,0x60,0x38,0x0C,0x06,0xC6,0xC6,0x7C,0x00,0x00,0x00,0x00}, // S
    {0x00,0x00,0xFF,0xDB,0x99,0x18,0x18,0x18,0x18,0x18,0x18,0x3C,0x00,0x00,0x00,0x00}, // T
    {0x00,0x00,0xC3,0xC3,0xC3,0xC3,0xC3,0xC3,0xC3,0xC3,0xC3,0x7E,0x00,0x00,0x00,0x00}, // U
    {0x00,0x00,0xC3,0xC3,0xC3,0xC3,0xC3,0xC3,0xC3,0x66,0x3C,0x18,0x00,0x00,0x00,0x00}, // V
    {0x00,0x00,0xC3,0xC3,0xC3,0xC3,0xDB,0xDB,0xFF,0x66,0x66,0x66,0x00,0x00,0x00,0x00}, // W
    {0x00,0x00,0xC3,0xC3,0x66,0x3C,0x18,0x3C,0x66,0xC3,0xC3,0xC3,0x00,0x00,0x00,0x00}, // X
    {0x00,0x00,0xC3,0xC3,0xC3,0x66,0x3C,0x18,0x18,0x18,0x18,0x3C,0x00,0x00,0x00,0x00}, // Y
    {0x00,0x00,0xFF,0xC3,0x86,0x0C,0x18,0x30,0x60,0xC1,0xC3,0xFF,0x00,0x00,0x00,0x00}, // Z
    {0x00,0x3C,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x3C,0x00,0x00,0x00,0x00}, // [
    {0x00,0x00,0x80,0xC0,0x60,0x30,0x18,0x0C,0x06,0x02,0x00,0x00,0x00,0x00,0x00,0x00}, // '\'
    {0x00,0x3C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x3C,0x00,0x00,0x00,0x00}, // ]
    {0x18,0x3C,0x66,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // ^
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xFF,0x00,0x00}, // _
    {0x30,0x18,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // `
    {0x00,0x00,0x00,0x00,0x00,0x78,0x0C,0x7C,0xCC,0xCC,0xCC,0x76,0x00,0x00,0x00,0x00}, // a
    {0x00,0x00,0xE0,0x60,0x60,0x7C,0x66,0x66,0x66,0x66,0x66,0x7C,0x00,0x00,0x00,0x00}, // b
    {0x00,0x00,0x00,0x00,0x00,0x7C,0xC6,0xC0,0xC0,0xC0,0xC6,0x7C,0x00,0x00,0x00,0x00}, // c
    {0x00,0x00,0x1C,0x0C,0x0C,0x7C,0xCC,0xCC,0xCC,0xCC,0xCC,0x76,0x00,0x00,0x00,0x00}, // d
    {0x00,0x00,0x00,0x00,0x00,0x7C,0xC6,0xFE,0xC0,0xC0,0xC6,0x7C,0x00,0x00,0x00,0x00}, // e
    {0x00,0x00,0x38,0x6C,0x64,0x60,0xF0,0x60,0x60,0x60,0x60,0xF0,0x00,0x00,0x00,0x00}, // f
    {0x00,0x00,0x00,0x00,0x00,0x76,0xCC,0xCC,0xCC,0xCC,0x7C,0x0C,0xCC,0x78,0x00,0x00}, // g
    {0x00,0x00,0xE0,0x60,0x60,0x6C,0x76,0x66,0x66,0x66,0x66,0xE7,0x00,0x00,0x00,0x00}, // h
    {0x00,0x00,0x18,0x18,0x00,0x78,0x18,0x18,0x18,0x18,0x18,0x7E,0x00,0x00,0x00,0x00}, // i
    {0x00,0x00,0x0C,0x0C,0x00,0x3C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0xCC,0x78,0x00,0x00}, // j
    {0x00,0x00,0xE0,0x60,0x60,0x66,0x6C,0x78,0x78,0x6C,0x66,0xE7,0x00,0x00,0x00,0x00}, // k
    {0x00,0x00,0x78,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x7E,0x00,0x00,0x00,0x00}, // l
    {0x00,0x00,0x00,0x00,0x00,0xFE,0xDB,0xDB,0xDB,0xDB,0xDB,0xDB,0x00,0x00,0x00,0x00}, // m
    {0x00,0x00,0x00,0x00,0x00,0xDC,0x66,0x66,0x66,0x66,0x66,0x66,0x00,0x00,0x00,0x00}, // n
    {0x00,0x00,0x00,0x00,0x00,0x7C,0xC6,0xC6,0xC6,0xC6,0xC6,0x7C,0x00,0x00,0x00,0x00}, // o
    {0x00,0x00,0x00,0x00,0x00,0xDC,0x66,0x66,0x66,0x66,0x7C,0x60,0x60,0xF0,0x00,0x00}, // p
    {0x00,0x00,0x00,0x00,0x00,0x76,0xCC,0xCC,0xCC,0xCC,0x7C,0x0C,0x0C,0x1E,0x00,0x00}, // q
    {0x00,0x00,0x00,0x00,0x00,0xDC,0x76,0x66,0x60,0x60,0x60,0xF0,0x00,0x00,0x00,0x00}, // r
    {0x00,0x00,0x00,0x00,0x00,0x7C,0xC6,0x60,0x38,0x0C,0xC6,0x7C,0x00,0x00,0x00,0x00}, // s
    {0x00,0x00,0x10,0x30,0x30,0xFC,0x30,0x30,0x30,0x30,0x34,0x18,0x00,0x00,0x00,0x00}, // t
    {0x00,0x00,0x00,0x00,0x00,0xCC,0xCC,0xCC,0xCC,0xCC,0xCC,0x76,0x00,0x00,0x00,0x00}, // u
    {0x00,0x00,0x00,0x00,0x00,0xC3,0xC3,0xC3,0xC3,0x66,0x3C,0x18,0x00,0x00,0x00,0x00}, // v
    {0x00,0x00,0x00,0x00,0x00,0xC3,0xC3,0xC3,0xDB,0xDB,0xFF,0x66,0x00,0x00,0x00,0x00}, // w
    {0x00,0x00,0x00,0x00,0x00,0xC3,0x66,0x3C,0x18,0x3C,0x66,0xC3,0x00,0x00,0x00,0x00}, // x
    {0x00,0x00,0x00,0x00,0x00,0xC3,0xC3,0xC3,0x66,0x3C,0x18,0x18,0x18,0x18,0x3C,0x00}, // y
    {0x00,0x00,0x00,0x00,0x00,0xFE,0xCC,0x18,0x30,0x60,0xC6,0xFE,0x00,0x00,0x00,0x00}, // z
    {0x00,0x0E,0x18,0x18,0x18,0x70,0x18,0x18,0x18,0x18,0x0E,0x00,0x00,0x00,0x00,0x00}, // {
    {0x00,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x00,0x00,0x00,0x00}, // |
    {0x00,0x70,0x18,0x18,0x18,0x0E,0x18,0x18,0x18,0x18,0x70,0x00,0x00,0x00,0x00,0x00}, // }
    {0x76,0xDC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}  // ~
};

/* Macros de commande des broches de contrôle (actives à l'état BAS) */
#define TFT_CS_LOW()    (GPIOB->BSRR = (uint32_t)GPIO_PIN_0 << 16U)
#define TFT_CS_HIGH()   (GPIOB->BSRR = GPIO_PIN_0)

#define TFT_WR_LOW()    (GPIOC->BSRR = (uint32_t)GPIO_PIN_1 << 16U)
#define TFT_WR_HIGH()   (GPIOC->BSRR = GPIO_PIN_1)

#define TFT_RS_LOW()    (GPIOC->BSRR = (uint32_t)GPIO_PIN_0 << 16U)
#define TFT_RS_HIGH()   (GPIOC->BSRR = GPIO_PIN_0)

/*
 * Écriture d'un octet sur le bus de données 8 bits
 * Correspondance physique Arduino Uno / Shield ITEAD -> STM32 NUCLEO-F446RE :
 *  D0 -> PA3
 *  D1 -> PA2
 *  D2 -> PA10
 *  D3 -> PB3
 *  D4 -> PB5
 *  D5 -> PB4
 *  D6 -> PB10
 *  D7 -> PA8
 */
static inline void TFT_SetBus(uint8_t val)
{
    // Port A : PA2, PA3, PA8, PA10
    uint32_t pa_set = 0;
    uint32_t pa_reset = 0;

    if (val & 0x01) pa_set |= GPIO_PIN_3;   else pa_reset |= GPIO_PIN_3;   // D0 -> PA3
    if (val & 0x02) pa_set |= GPIO_PIN_2;   else pa_reset |= GPIO_PIN_2;   // D1 -> PA2
    if (val & 0x04) pa_set |= GPIO_PIN_10;  else pa_reset |= GPIO_PIN_10;  // D2 -> PA10
    if (val & 0x80) pa_set |= GPIO_PIN_8;   else pa_reset |= GPIO_PIN_8;   // D7 -> PA8

    GPIOA->BSRR = pa_set | (pa_reset << 16U);

    // Port B : PB3, PB4, PB5, PB10
    uint32_t pb_set = 0;
    uint32_t pb_reset = 0;

    if (val & 0x08) pb_set |= GPIO_PIN_3;   else pb_reset |= GPIO_PIN_3;   // D3 -> PB3
    if (val & 0x10) pb_set |= GPIO_PIN_5;   else pb_reset |= GPIO_PIN_5;   // D4 -> PB5
    if (val & 0x20) pb_set |= GPIO_PIN_4;   else pb_reset |= GPIO_PIN_4;   // D5 -> PB4
    if (val & 0x40) pb_set |= GPIO_PIN_10;  else pb_reset |= GPIO_PIN_10;  // D6 -> PB10

    GPIOB->BSRR = pb_set | (pb_reset << 16U);
}

/* Envoi d'une commande (RS = 0) */
void TFT_WriteCmd(uint8_t cmd)
{
    TFT_RS_LOW();
    TFT_CS_LOW();
    TFT_SetBus(cmd);
    TFT_WR_LOW();
    __NOP();
    TFT_WR_HIGH();
    TFT_CS_HIGH();
}

/* Envoi d'une donnée (RS = 1) */
void TFT_WriteData(uint8_t data)
{
    TFT_RS_HIGH();
    TFT_CS_LOW();
    TFT_SetBus(data);
    TFT_WR_LOW();
    __NOP();
    TFT_WR_HIGH();
    TFT_CS_HIGH();
}

/* Envoi de 16 bits de données */
void TFT_WriteData16(uint16_t data)
{
    TFT_WriteData((uint8_t)(data >> 8));
    TFT_WriteData((uint8_t)(data & 0xFF));
}

#if defined(TFT_CONTROLLER_S6D1121)
static void S6D1121_WriteReg(uint8_t reg, uint16_t val)
{
    TFT_WriteCmd(reg);
    TFT_WriteData16(val);
}
#endif

/* Délimitation de la zone mémoire d'affichage (GRAM) */
void TFT_SetWindow(uint16_t x0, uint16_t y0, uint16_t x1, uint16_t y1)
{
#if defined(TFT_CONTROLLER_ILI9341)
    TFT_WriteCmd(0x2A); // Column Address Set
    TFT_WriteData((uint8_t)(x0 >> 8));
    TFT_WriteData((uint8_t)(x0 & 0xFF));
    TFT_WriteData((uint8_t)(x1 >> 8));
    TFT_WriteData((uint8_t)(x1 & 0xFF));

    TFT_WriteCmd(0x2B); // Page Address Set
    TFT_WriteData((uint8_t)(y0 >> 8));
    TFT_WriteData((uint8_t)(y0 & 0xFF));
    TFT_WriteData((uint8_t)(y1 >> 8));
    TFT_WriteData((uint8_t)(y1 & 0xFF));

    TFT_WriteCmd(0x2C); // Memory Write
#elif defined(TFT_CONTROLLER_S6D1121)
    S6D1121_WriteReg(0x46, (x1 << 8) | x0);
    S6D1121_WriteReg(0x48, y0);
    S6D1121_WriteReg(0x47, y1);
    S6D1121_WriteReg(0x20, x0);
    S6D1121_WriteReg(0x21, y0);
    TFT_WriteCmd(0x22);
#endif
}

/* Initialisation du contrôleur graphique */
void TFT_Init(void)
{
    TFT_CS_HIGH();
    TFT_WR_HIGH();
    TFT_RS_HIGH();
    HAL_Delay(100);

#if defined(TFT_CONTROLLER_ILI9341)
    TFT_WriteCmd(0x01); // Software Reset
    HAL_Delay(150);

    TFT_WriteCmd(0x28); // Display OFF

    TFT_WriteCmd(0xCF);
    TFT_WriteData(0x00); TFT_WriteData(0x83); TFT_WriteData(0x30);

    TFT_WriteCmd(0xED);
    TFT_WriteData(0x64); TFT_WriteData(0x03); TFT_WriteData(0x12); TFT_WriteData(0x81);

    TFT_WriteCmd(0xE8);
    TFT_WriteData(0x85); TFT_WriteData(0x01); TFT_WriteData(0x79);

    TFT_WriteCmd(0xCB);
    TFT_WriteData(0x39); TFT_WriteData(0x2C); TFT_WriteData(0x00); TFT_WriteData(0x34); TFT_WriteData(0x02);

    TFT_WriteCmd(0xF7);
    TFT_WriteData(0x20);

    TFT_WriteCmd(0xEA);
    TFT_WriteData(0x00); TFT_WriteData(0x00);

    TFT_WriteCmd(0xC0); // Power Control 1
    TFT_WriteData(0x26);

    TFT_WriteCmd(0xC1); // Power Control 2
    TFT_WriteData(0x11);

    TFT_WriteCmd(0xC5); // VCOM Control 1
    TFT_WriteData(0x35); TFT_WriteData(0x3E);

    TFT_WriteCmd(0xC7); // VCOM Control 2
    TFT_WriteData(0xBE);

    TFT_WriteCmd(0x36); // Memory Access Control (Orientation portrait)
    TFT_WriteData(0x08);

    TFT_WriteCmd(0x3A); // Pixel Format Set: 16 bits/pixel (RGB 5-6-5)
    TFT_WriteData(0x55);

    TFT_WriteCmd(0xB1); // Frame Rate Control
    TFT_WriteData(0x00); TFT_WriteData(0x1B);

    TFT_WriteCmd(0xF2); // 3Gamma Function Disable
    TFT_WriteData(0x08);

    TFT_WriteCmd(0x26); // Gamma curve selected
    TFT_WriteData(0x01);

    TFT_WriteCmd(0xE0); // Set Gamma
    TFT_WriteData(0x1F); TFT_WriteData(0x1A); TFT_WriteData(0x18); TFT_WriteData(0x0A);
    TFT_WriteData(0x0F); TFT_WriteData(0x06); TFT_WriteData(0x45); TFT_WriteData(0x87);
    TFT_WriteData(0x32); TFT_WriteData(0x0A); TFT_WriteData(0x07); TFT_WriteData(0x02);
    TFT_WriteData(0x07); TFT_WriteData(0x05); TFT_WriteData(0x00);

    TFT_WriteCmd(0xE1); // Set Gamma
    TFT_WriteData(0x00); TFT_WriteData(0x25); TFT_WriteData(0x27); TFT_WriteData(0x05);
    TFT_WriteData(0x10); TFT_WriteData(0x09); TFT_WriteData(0x3A); TFT_WriteData(0x78);
    TFT_WriteData(0x4D); TFT_WriteData(0x05); TFT_WriteData(0x18); TFT_WriteData(0x0D);
    TFT_WriteData(0x38); TFT_WriteData(0x3A); TFT_WriteData(0x1F);

    TFT_WriteCmd(0x11); // Sleep OUT
    HAL_Delay(120);

    TFT_WriteCmd(0x29); // Display ON
    HAL_Delay(20);

#elif defined(TFT_CONTROLLER_S6D1121)
    S6D1121_WriteReg(0x11, 0x2004);
    S6D1121_WriteReg(0x13, 0xCC00);
    S6D1121_WriteReg(0x15, 0x2600);
    S6D1121_WriteReg(0x14, 0x252A);
    S6D1121_WriteReg(0x12, 0x0033);
    S6D1121_WriteReg(0x13, 0xCC04);
    HAL_Delay(10);
    S6D1121_WriteReg(0x13, 0xCC06);
    HAL_Delay(10);
    S6D1121_WriteReg(0x13, 0xCC4F);
    HAL_Delay(10);
    S6D1121_WriteReg(0x13, 0x674F);
    S6D1121_WriteReg(0x11, 0x2003);
    HAL_Delay(30);
    S6D1121_WriteReg(0x30, 0x2609);
    S6D1121_WriteReg(0x31, 0x242C);
    S6D1121_WriteReg(0x32, 0x0423);
    S6D1121_WriteReg(0x33, 0x2425);
    S6D1121_WriteReg(0x34, 0x2226);
    S6D1121_WriteReg(0x35, 0x0F00);
    S6D1121_WriteReg(0x36, 0x0104);
    S6D1121_WriteReg(0x37, 0x1427);
    S6D1121_WriteReg(0x38, 0x2066);
    S6D1121_WriteReg(0x39, 0x0703);
    S6D1121_WriteReg(0x01, 0x011C);
    S6D1121_WriteReg(0x02, 0x0100);
    S6D1121_WriteReg(0x03, 0x1030); // 16 bits RGB 5-6-5
    S6D1121_WriteReg(0x07, 0x0011);
    S6D1121_WriteReg(0x08, 0x0808);
    S6D1121_WriteReg(0x0B, 0x1100);
    S6D1121_WriteReg(0x0C, 0x0000);
    S6D1121_WriteReg(0x0F, 0x1401);
    S6D1121_WriteReg(0x07, 0x0012);
    HAL_Delay(20);
    S6D1121_WriteReg(0x07, 0x0017);
#endif
}

/* Remplissage de tout l'écran avec une couleur RGB565 */
void TFT_FillScreen(uint16_t color)
{
    TFT_SetWindow(0, 0, TFT_WIDTH - 1, TFT_HEIGHT - 1);

    uint8_t hi = (uint8_t)(color >> 8);
    uint8_t lo = (uint8_t)(color & 0xFF);

    TFT_RS_HIGH();
    TFT_CS_LOW();

    uint32_t total = (uint32_t)TFT_WIDTH * TFT_HEIGHT;
    for (uint32_t i = 0; i < total; i++)
    {
        // Envoi de l'octet haut
        TFT_SetBus(hi);
        TFT_WR_LOW();
        __NOP();
        TFT_WR_HIGH();

        // Envoi de l'octet bas
        TFT_SetBus(lo);
        TFT_WR_LOW();
        __NOP();
        TFT_WR_HIGH();
    }

    TFT_CS_HIGH();
}

/* Dessin d'un pixel */
void TFT_DrawPixel(uint16_t x, uint16_t y, uint16_t color)
{
    if (x >= TFT_WIDTH || y >= TFT_HEIGHT) return;
    TFT_SetWindow(x, y, x, y);
    TFT_WriteData16(color);
}

/* Dessin d'un caractère avec multiplicateur de taille */
void TFT_DrawChar(uint16_t x, uint16_t y, char c, uint16_t color, uint16_t bg, uint8_t size)
{
    if (c < 32 || c > 126) c = ' ';
    uint8_t char_index = (uint8_t)(c - 32);

    for (uint8_t row = 0; row < 16; row++)
    {
        uint8_t line = font_8x16[char_index][row];
        for (uint8_t col = 0; col < 8; col++)
        {
            uint16_t pixel_color = (line & (0x80 >> col)) ? color : bg;

            if (size == 1)
            {
                TFT_DrawPixel(x + col, y + row, pixel_color);
            }
            else
            {
                // Agrandissement par pavés size x size
                for (uint8_t sx = 0; sx < size; sx++)
                {
                    for (uint8_t sy = 0; sy < size; sy++)
                    {
                        TFT_DrawPixel(x + col * size + sx, y + row * size + sy, pixel_color);
                    }
                }
            }
        }
    }
}

/* Affichage d'une chaîne de caractères */
void TFT_DrawString(uint16_t x, uint16_t y, const char *str, uint16_t color, uint16_t bg, uint8_t size)
{
    uint16_t cur_x = x;
    uint16_t cur_y = y;

    while (*str)
    {
        if (*str == '\n')
        {
            cur_x = x;
            cur_y += 16 * size;
        }
        else
        {
            TFT_DrawChar(cur_x, cur_y, *str, color, bg, size);
            cur_x += 8 * size;
        }
        str++;
    }
}
